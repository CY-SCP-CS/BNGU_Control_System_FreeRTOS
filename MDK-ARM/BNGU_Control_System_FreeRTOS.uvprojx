# Keil uVision project BNGU_Control_System_FreeRTOS.uvprojx, settings and files
target BNGU_Control_System_FreeRTOS (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BNGU_Control_System_FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,APP_RTOS_ENABLE_EXAMPLES=0,CURRENT_ROBOT=ROBOT_SENTRY,APP_UI_MODE=0,CURRENT_BOARD=BOARD_GIMBAL,APP_LOG_VOFA=0
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Self_core/App/Modules/shoot;../Self_core/App/Modules/shoot/internal;../Self_core/App/Contracts;../Self_core/Lib/Lib_math;../Self_core;../Self_core/App/Config;../Self_core/Lib/Lib_Typedef;../Self_core/Lib/Lib_filter;../Self_core/Lib/Lib_pid;../Self_core/Os/FreeRTOS;../Self_core/Os/Port;../Self_core/Drv/Drv_buzzer;../Self_core/Drv/Drv_dbus;../Self_core/Drv/Drv_game_controller;../Self_core/Drv/Drv_imu;../Self_core/Drv/Drv_led;../Self_core/Drv/Drv_mag;../Self_core/Drv/Drv_melody;../Self_core/Drv/Drv_motor;../Self_core/Drv/Drv_power_measure;../Self_core/Drv/Drv_referee;../Self_core/Drv/Drv_vofa;../Self_core/Drv;../Self_core/App/Runtime;../Self_core/App/Modules/can;../Self_core/App/Modules/can/internal;../Self_core/App/Modules/health;../Self_core/Bsp;../Self_core/App/Modules/dbus;../Self_core/App/Modules/dbus/internal;../Self_core/App/Modules/referee;../Self_core/App/Modules/referee/internal;../Self_core/App/Modules/ui;../Self_core/App/Modules/imu;../Self_core/App/Modules/imu/internal;../Self_core/App/Modules/health/internal;../Self_core/App/Modules/log;../Self_core/App/Modules/log/internal;../Self_core/App/Modules/telemetry;../Self_core/App/Modules/telemetry/internal;../Self_core/App/Modules/ui/internal;../Self_core/App/Modules/ui/ui_generated;../Self_core/App/Vehicles/Sentry/Gimbal/Shoot;../Self_core/App/Vehicles/Sentry/Gimbal/Shoot/internal;../Self_core/App/Modules/control_support/internal;../Self_core/App/Modules/control_support;../Self_core/App/Vehicles/Sentry/Gimbal;../Self_core/App/Vehicles/Sentry/Gimbal/internal;../Self_core/App/Runtime/internal;../Self_core/App/Assembly;../Self_core/App/Vehicles/Armored/Chassis/internal;../Self_core/App/Vehicles/Sentry/Chassis/internal;../Self_core/App/Vehicles/Navigation/Chassis/internal;../Self_core/App/Vehicles/Armored/Chassis;../Self_core/App/Vehicles/Sentry/Chassis;../Self_core/App/Vehicles/Navigation/Chassis
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Hardware/I2C3
    ../Core/Src/: i2c.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c
  group Self_core/Os/FreeRTOS
    ../Self_core/Os/FreeRTOS/: app_rtos_objects.c app_rtos_kernel.c
  group Self_core/Os/Port
    ../Self_core/Os/Port/: app_rtos_port.c
  group Self_core/App/Modules/shoot
    ../Self_core/App/Modules/shoot/: app_task_shoot.c
  group Self_core/App/Modules/can
    ../Self_core/App/Modules/can/: app_chassis_comm.c app_gimbal_comm.c app_vehicle_can.c app_core_protocol.c app_task_can.c app_task_can_port.c
  group Self_core/App/Modules/dbus
    ../Self_core/App/Modules/dbus/: app_control.c app_task_dbus.c app_task_dbus_port.c
  group Self_core/App/Modules/referee
    ../Self_core/App/Modules/referee/: app_task_referee.c app_task_referee_port.c
  group Self_core/App/Modules/imu
    ../Self_core/App/Modules/imu/: app_task_imu.c app_task_imu_port.c
  group Self_core/App/Modules/health
    ../Self_core/App/Modules/health/: app_task_health.c app_task_monitor.c
  group Self_core/App/Modules/log
    ../Self_core/App/Modules/log/: app_task_log.c app_task_log_port.c
  group Self_core/App/Modules/telemetry
    ../Self_core/App/Modules/telemetry/: app_task_telemetry.c
  group Self_core/App/Modules/ui
    ../Self_core/App/Modules/ui/: app_Armored_ui.c app_ui_io.c app_ui_service.c app_ui_port.c
  group Self_core/App/Modules/ui/ui_generated
    ../Self_core/App/Modules/ui/ui_generated/: ui_g.c ui_interface.c
  group Self_core/App/Vehicles/Sentry/Gimbal/Shoot
    ../Self_core/App/Vehicles/Sentry/Gimbal/Shoot/: app_task_shoot_control.c app_sentry_shoot.c
  group Self_core/App/Vehicles/Sentry/Gimbal
    ../Self_core/App/Vehicles/Sentry/Gimbal/: app_sentry_gimbal.c app_task_gimbal.c app_task_gimbal_port.c
  group Self_core/App/Runtime
    ../Self_core/App/Runtime/: app_rtos.c app_tasks.c
  group Self_core/App/Assembly
    ../Self_core/App/Assembly/: app_rtos_board.c app_task_init.c app_rtos_setup.c
  group Self_core/Drv/Drv_game_controller
    ../Self_core/Drv/Drv_game_controller/: drv_game_controller.c
  group Self_core/Drv/Drv_buzzer
    ../Self_core/Drv/Drv_buzzer/: drv_buzzer.c drv_buzzer_port.c
  group Self_core/Drv/Drv_dbus
    ../Self_core/Drv/Drv_dbus/: drv_dbus.c drv_dbus_port.c
  group Self_core/Drv/Drv_imu
    ../Self_core/Drv/Drv_imu/: drv_imu_ekf.c drv_imu_vqf.c drv_imu.c drv_imu_port.c
  group Self_core/Drv/Drv_mag
    ../Self_core/Drv/Drv_mag/: drv_mag.c drv_mag_port.c
  group Self_core/Drv/Drv_led
    ../Self_core/Drv/Drv_led/: drv_led.c drv_led_port.c
  group Self_core/Drv/Drv_melody
    ../Self_core/Drv/Drv_melody/: drv_melody.c
  group Self_core/Drv/Drv_motor
    ../Self_core/Drv/Drv_motor/: drv_motor.c drv_motor_port.c
  group Self_core/Drv/Drv_power_measure
    ../Self_core/Drv/Drv_power_measure/: drv_power_measure.c drv_power_measure_port.c
  group Self_core/Drv/Drv_referee
    ../Self_core/Drv/Drv_referee/: drv_referee.c drv_referee_port.c
  group Self_core/Drv/Drv_vofa
    ../Self_core/Drv/Drv_vofa/: drv_vofa.c
  group Self_core/Bsp
    ../Self_core/Bsp/: bsp_adc.c bsp_can.c bsp_flash.c bsp_gpio.c bsp_i2c.c bsp_spi.c bsp_tim.c bsp_uart.c
  group Self_core/Lib/Lib_filter
    ../Self_core/Lib/Lib_filter/: lib_filter.c
  group Self_core/Lib/Lib_math
    ../Self_core/Lib/Lib_math/: lib_math.c lib_periodic.c
  group Self_core/Lib/Lib_pid
    ../Self_core/Lib/Lib_pid/: lib_pid.c
software components: CMSIS:CORE 4.3.0
